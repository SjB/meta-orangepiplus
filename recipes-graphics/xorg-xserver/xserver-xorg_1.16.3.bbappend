EXTRA_OECONF_append = " --disable-systemd-logind"
