PACKAGECONFIG_remove = "egl gles"

